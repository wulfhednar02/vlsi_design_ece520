* Circuit Extracted by Tanner Research's L-Edit V7.12 / Extract V4.00 ;
* TDB File:  C:\Users\Don\Google Drive\UNM Classes\VLSI Design\Project\Tanner\vlsi_design\layouts\Inverter_P_Strong_v7, Cell:  Inverter_P_Strong
* Extract Definition File:  C:\Users\Don\Google Drive\UNM Classes\VLSI Design\Project\Tanner\vlsi_design\layouts\ON_C5N.ext
* Extract Date and Time:  03/25/2019 - 21:39

.INCLUDE ON_C5N.modlib

* WARNING:  Layers with Unassigned AREA Capacitance.
*   <Substrate>
*   <ChipSubstrate>
* WARNING:  Layers with Unassigned FRINGE Capacitance.
*   <pdiff>
*   <n well wire>
*   <ndiff>
*   <Substrate>
*   <ChipSubstrate>
* WARNING:  Layers with Zero Resistance.
*   <Substrate>
*   <ChipSubstrate>

* NODE NAME ALIASES
*       1 = GND (0,-36.5)
*       2 = VDD (0,37.5)
*       3 = Output (110.5,0.5)
*       4 = Input (5.5,0.5)

Cpar1 GND 0 22.47908f
Cpar2 VDD 0 245.67962f
Cpar3 Output 0 181.89832f
Cpar4 Input 0 11.435182f

M5 Output Input GND GND CMOSN L=0.6u W=3u AD=4.95p PD=9.3u AS=4.95p PS=9.3u
* M5 DRAIN GATE SOURCE BULK (100 -16.5 102 -6.5)
M6 VDD Input Output VDD CMOSP L=0.6u W=8.25u AD=101.475p PD=140.1u AS=90.3375p PS=120.9u
* M6 DRAIN GATE SOURCE BULK (102 6 104 33.5)
M7 Output Input VDD VDD CMOSP L=0.6u W=8.25u AD=90.3375p PD=120.9u AS=101.475p PS=140.1u
* M7 DRAIN GATE SOURCE BULK (94 6 96 33.5)
M8 VDD Input Output VDD CMOSP L=0.6u W=8.25u AD=101.475p PD=140.1u AS=90.3375p PS=120.9u
* M8 DRAIN GATE SOURCE BULK (86 6 88 33.5)
M9 Output Input VDD VDD CMOSP L=0.6u W=8.25u AD=90.3375p PD=120.9u AS=101.475p PS=140.1u
* M9 DRAIN GATE SOURCE BULK (77.5 6 79.5 33.5)
M10 VDD Input Output VDD CMOSP L=0.6u W=8.25u AD=101.475p PD=140.1u AS=90.3375p PS=120.9u
* M10 DRAIN GATE SOURCE BULK (69.5 6 71.5 33.5)
M11 Output Input VDD VDD CMOSP L=0.6u W=8.25u AD=90.3375p PD=120.9u AS=101.475p PS=140.1u
* M11 DRAIN GATE SOURCE BULK (61.5 6 63.5 33.5)
M12 VDD Input Output VDD CMOSP L=0.6u W=8.25u AD=101.475p PD=140.1u AS=90.3375p PS=120.9u
* M12 DRAIN GATE SOURCE BULK (53.5 6 55.5 33.5)
M13 Output Input VDD VDD CMOSP L=0.6u W=8.25u AD=90.3375p PD=120.9u AS=101.475p PS=140.1u
* M13 DRAIN GATE SOURCE BULK (45.5 6 47.5 33.5)
M14 VDD Input Output VDD CMOSP L=0.6u W=8.25u AD=101.475p PD=140.1u AS=90.3375p PS=120.9u
* M14 DRAIN GATE SOURCE BULK (37.5 6 39.5 33.5)
M15 Output Input VDD VDD CMOSP L=0.6u W=8.25u AD=90.3375p PD=120.9u AS=101.475p PS=140.1u
* M15 DRAIN GATE SOURCE BULK (29.5 6 31.5 33.5)
M16 VDD Input Output VDD CMOSP L=0.6u W=8.25u AD=101.475p PD=140.1u AS=90.3375p PS=120.9u
* M16 DRAIN GATE SOURCE BULK (21.5 6 23.5 33.5)
M17 Output Input VDD VDD CMOSP L=0.6u W=8.25u AD=90.3375p PD=120.9u AS=101.475p PS=140.1u
* M17 DRAIN GATE SOURCE BULK (13.5 6 15.5 33.5)

* Total Nodes: 4
* Total Elements: 17
* Extract Elapsed Time: 0 seconds
.END
